options:
  parameters:
    author: Andreas Slovacek
    generate_options: qt_gui
    id: spectrum_sweeper
    output_language: python
    title: Spectrum Sweeper
  states: {}

blocks:
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: filename
    max_seg_size: nsegments
    rel_rate: '1'
    samp_rate: samp_rate/dec_fac
    type: float
    vlen: nfft
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: dec_fac
    type: complex
    vlen: nfft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: dec_fac
  id: parameter
  parameters:
    label: Decimation Factor
    type: intx
    value: '16'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nfft)
  states: {}
- name: filename
  id: parameter
  parameters:
    label: Filename
    type: str
    value: /home/ace/work/UsrpB210/data/out_dat
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: max_bandwidth
  id: parameter
  parameters:
    label: USRPB210 Max Bandwidth
    type: eng_float
    value: 56e6
  states: {}
- name: max_bound
  id: parameter
  parameters:
    label: USRPB210Max Freq
    type: eng_float
    value: 6000e6
  states: {}
- name: max_sample_rate
  id: parameter
  parameters:
    label: USRPB210 Max Sample Rate
    type: eng_float
    value: 61.44e6
  states: {}
- name: min_bound
  id: parameter
  parameters:
    label: USRPB210 Min Freq
    type: eng_float
    value: 70e6
  states: {}
- name: nfft
  id: parameter
  parameters:
    label: FFT Size
    type: intx
    value: '4096'
  states: {}
- name: nsegments
  id: parameter
  parameters:
    type: intx
    value: '116'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 50e6
  states: {}
- name: start_freq
  id: parameter
  parameters:
    label: Starting Frequency
    type: eng_float
    value: 96e6
  states: {}
- name: stop_freq
  id: parameter
  parameters:
    label: End Frequency
    type: eng_float
    value: 5930e6
  states: {}
- name: stream_chan
  id: parameter
  parameters:
    label: Stream Channels
    value: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: start_freq
    gain0: '0'
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_keep_one_in_n_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
